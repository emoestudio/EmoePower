# Repository emoestudio/EmoePower

File README.md:

# Overview

This is a pocket-sized, IoT-ed Power Supply.

It's final goal is to meet EEers' daily usage requirements:

- Small Sized  
- Programmable Voltage and Current settings  
- High Efficiency  
- High Reliability  
- High precision
- Multiple control method  
- Modernized GUI  

**This project is still under development and test.**

## V1.0 PCB

## LM5175 Parameter Configuration & Calculation

| Design Requirements | Calculated Value |
| ------------------- | ---------------- |
| Input Voltage Range | 20V ~ 24V |
| Output Range | 0.8V(Minimal) ~ 24V |
| Load Current | 0 ~ 4A(0-12V),0 ~ 2A(12-24V) |
| Switching Frequency | about 300KHz |
| Mode | CCM & Hiccup On |

### Frequency Calc

Finally get Rt = 84.5kΩ and we select standard value, that is 82kΩ.  

### Inductor Selection

}-V_{OUT})*V_{OUT}}}%20\over%20{0.4*I_{OUT(MAX)}*F_{SW}*V_{IN(MAX)}}})

In most cases, circuit works in BUCK mode, so choose a most-common used voltage range, and calculate its L, finally we get L is about 10uH.

And the maximum average inductor current occurs at the minimum input and maximum load current:

}%20=%20{{V_{OUT}*I_{OUT(MAX)}}%20\over%20{0.9*V_{IN(MIN)}}})

}%20=%20I_{L(MAX)}%20+%20{{V_{IN(MIN)}*(V_{OUT}-V_{IN(MIN)})}%20\over%20{2*L_1*F_{SW}*V_{OUT}}})

And Saturation current should be higher, about 1.5xIL, about 20A.

Finally we choose two 1265 4.7uH in series.

### What's left...
Please refer to ti's [docs](https://www.ti.com/lit/ds/symlink/lm5175.pdf?ts=1611563386531&ref_url=https%253A%252F%252Fwww.google.com%252F)

## KiCad design Hardware_Kicad/EmoePower_V1.0.kicad_pcb

Parts:
C1: 50V 100uF; CP_Elec_8x10.5
C2: 47pF; C_0603_1608Metric
C3, C5, C6, C8, C9: 4.7uF; C_1206_3216Metric
C4, C7, C10, C15, C18: 0.1uF; C_0603_1608Metric
C11, C12, C13, C14, C16: 10uF; C_1206_3216Metric
C17, C19: 50V 220uF; CP_Elec_10x10.5
CBoot1, CBoot2: 0.1uF; C_0603_1608Metric
C_Slope1: 470pF; C_0603_1608Metric
Cc1: 22nF; C_0603_1608Metric
Cc2: 100pF; C_0603_1608Metric
Css1, Css2: 0.1uF; C_0603_1608Metric
D1: 1n4007; D_SMA
D2, D3: MBR0520LT; D_SOD-323
D4: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J1: PWR_IN; JST_VH_B2P-VH-B_1x02_P3.96mm_Vertical
J2: DAC; PinHeader_1x03_P2.54mm_Vertical
J3: Mode_Switch; PinHeader_1x03_P2.54mm_Vertical
J4: PWR_OUT; JST_VH_B2P-VH-B_1x02_P3.96mm_Vertical
L1, L2: 4.7uH; L_Wuerth_HCI-1365
Q1, Q2, Q3, Q4: IRLR8726TRPBF; TO-252-2
R1, R2, R9: 100; R_0603_1608Metric
R3, R5, R6: 10; R_0603_1608Metric
R4: 10k; R_0603_1608Metric
R7: 280k; R_0603_1608Metric
R8, R11: 20k; R_0603_1608Metric
R10: 180k; R_0603_1608Metric
R12: 4.7k; R_0603_1608Metric
R13, R14, R15, R16, R17: 0; R_0805_2012Metric
R_Mode1: 93.1k; R_0603_1608Metric
R_SENSE1: 8m; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R_SENSE2: 25m; R_2512_6332Metric_Pad1.40x3.35mm_HandSolder
R_T1: 82k; R_0603_1608Metric
Rc1: 10k; R_0603_1608Metric
Ruv1: 56k; R_0603_1608Metric
Ruv2: 240k; R_0603_1608Metric
U1: MP1584-3A; MP1584
U2: LM5175PWP; HTSSOP-28-1EP_4.4x9.7mm_P0.65mm_EP3.4x9.5mm_ThermalVias
U3: MAX4080T; SOIC-8_3.9x4.9mm_P1.27mm
U4: MAX907; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+5V: C10.1, C18.1, U3.2 (Vcc), U4.8 (V+); also elsewhere on the board
/0.1Vout: R5.1, R10.1, R11.2
/DAC_Current: J2.2, U4.3 (+)
/DAC_Voltage: J2.3, U4.5 (+)
/DigitalFB: J3.1, R9.2
/FeedBack: J3.2, U2.11 (FB)
/I-V_Out: R6.1, U3.5 (OUT)
/Vout: C7.2, C17.1, C19.1, J4.1, R7.2, R10.2, R_SENSE2.1, U2.12 (VOSNS), U2.24 (BIAS), U3.8 (RS-)
GNDA: C4.1, C7.1, C10.2, C15.2, C18.2, C_Slope1.1, Cc2.2, Css1.2, Css2.2, J2.1, R17.2, R_Mode1.1, R_T1.1, Rc1.1, Ruv1.2, U2.5 (DITH), U2.10 (AGND), U2.29 (PowerPAD), U3.4 (GND), U4.4 (V-); also elsewhere on the board
GNDPWR: C1.2, C3.2, C5.2, C6.2, C8.2, C9.2, C11.2, C12.2, C13.2, C14.2, C16.2, C17.2, C19.2, D4.1 (K), J1.1, J4.2, R2.1, R8.1, R11.1, R17.1, R_SENSE1.2, U2.22 (PGND)
unnamed: C2.1, R2.2, U2.15 (CSG)
unnamed: C2.2, R1.2, U2.16 (CS)
unnamed: C11.1, C12.1, C13.1, C14.1, C16.1, Q3.2 (D), R_SENSE2.2, U3.1 (RS+)
unnamed: C15.1, R5.2, U4.6 (-)
unnamed: CBoot1.1, L1.1, Q1.3 (S), Q2.2 (D), U2.28 (SW1)
unnamed: CBoot1.2, D2.1 (K), U2.26 (BOOT1)
unnamed: CBoot2.1, D3.1 (K), U2.20 (BOOT2)
unnamed: CBoot2.2, L2.2, Q3.3 (S), Q4.2 (D), U2.18 (SW2)
unnamed: C_Slope1.2, U2.7 (SLOPE)
unnamed: Cc1.1, Cc2.1, U2.9 (COMP)
unnamed: Cc1.2, Rc1.2
unnamed: Css1.1, U2.8 (SS)
unnamed: Css2.1, R3.1, U2.2 (VIN)
unnamed: D1.1 (K), R3.2
unnamed: D4.2 (A), R12.1
unnamed: J3.3, R7.1, R8.2
unnamed: L1.2, L2.1
unnamed: Q1.1 (G), R14.2
unnamed: Q2.1 (G), R13.1
unnamed: Q2.3 (S), Q4.3 (S), R1.1, R_SENSE1.1
unnamed: Q3.1 (G), R16.2
unnamed: Q4.1 (G), R15.2
unnamed: R4.2, U2.17 (PGOOD)
unnamed: R6.2, U4.2 (-)
unnamed: R9.1, U4.1, U4.7
unnamed: R13.2, U2.25 (LDRV1)
unnamed: R14.1, U2.27 (HDRV1)
unnamed: R15.1, U2.21 (LDRV2)
unnamed: R16.1, U2.19 (HDRV2)
unnamed: R_Mode1.2, U2.4 (MODE)
unnamed: R_T1.2, U2.6 (RT/SYNC)
unnamed: Ruv1.1, Ruv2.1, U2.1 (EN/UVLO)
unnamed: U2.13 (ISNS(-)), U2.14 (ISNS(+))
VCC: C4.2, D2.2 (A), D3.2 (A), R4.1, U2.23 (VCC)
VDC: C1.1, C3.1, C5.1, C6.1, C8.1, C9.1, D1.2 (A), J1.2, Q1.2 (D), R12.2, Ruv2.2, U2.3 (VISNS); also elsewhere on the board

Notes on the sheet:
LM5175 20V Input 0.8-24V 0-2A Output

Board: 2 copper layers, 82.0 x 52.0 mm, 68 parts (0 on the bottom side), 45 nets.

Other parts of the board:
MP1584-5.0: MP1584-3A; MP1584

Their connections:
+5V: MP1584-5.0.3; also elsewhere on the board
GNDA: MP1584-5.0.1, MP1584-5.0.4; also elsewhere on the board
VDC: MP1584-5.0.2; also elsewhere on the board

## Commit log

2021-01-25 Create Maven Project For Desktop Controller Software
2021-01-25 Network Module
2021-01-25 Drawing GUI with Swing
2021-01-25 Add README file
2021-01-25 Change for online mathjax
2021-01-27 Upload PCB_V1.0 Design
2021-01-29 继续完成后端部分

Notices in the files:
Hardware_Kicad/EmoePower_V1.0.kicad_pcb:
©Floydfish-2021
